# IAR project LarsLCD.ewp, settings and files
configuration Sense (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430G2553 MSP430G2553
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430G2553.xcl
  XLINK.XlinkStackSize: 1
configuration Simple (MSP430, debug)
  as the first configuration, except:
  ICC430.CCOptLevel: 1
configuration Game (MSP430, debug)
  as the first configuration, except:
configuration DotFactory (MSP430, debug)
  as the first configuration, except:
  ICC430.CCOptLevel: 1
configuration LCD-Test (MSP430, debug)
  as the first configuration, except:
  ICC430.CCOptLevel: 1
  group (top)
    ./: main_game.c main_lcd_chartest.c main_lcd_dotfactory.c main_lcd_simple.c
  group LCD
    ./: dotfactory.c lcd.c lcd.h lcd_charset.c lcd_charset.h
  group sense
    ./: CTS_HAL.c CTS_HAL.h CTS_Layer.c CTS_Layer.h main_touch_lcd.c sense_structure.c sense_structure.h
